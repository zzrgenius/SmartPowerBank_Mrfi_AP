# IAR project Ap_as_Data_Hub.ewp, settings and files
configuration CC1101-Access Point (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MRFI_CC1101
  ICCARM.IExtraOptions: -f "Configuration\Access_Point\smpl_config.dat"; -f "Configuration\smpl_nwk_config.dat"
  ICCARM.CCIncludePath2: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\STM32; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\..\..\Components\SimpliciTI\nwk_applications; ..\..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport; ..\..\..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Ap_as_Data_Hub.srec
  ILINK.IlinkOutputFile: Ap_as_Data_Hub.out
  ILINK.IlinkIcfFile: D:\TI\SimpliciTI\Components\bsp\boards\STM32\stm32f103RE_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CC1101-Channel Sniffer (ARM, debug)
  as the first configuration, except:
  ICCARM.IExtraOptions: -f "Configuration\Channel_Sniffer\smpl_config.dat"; -f "Configuration\smpl_nwk_config.dat"
  ICCARM.CCOptLevel: 3
configuration CC1101-Range Extender (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.IExtraOptions: -f "Configuration\Range_Extender\smpl_config.dat"; -f "Configuration\smpl_nwk_config.dat"
  ICCARM.CCOptLevel: 3
configuration CC1101-End Device (ARM, debug)
  as the first configuration, except:
  ICCARM.IExtraOptions: -f "Configuration\End_Device\smpl_config.dat"; -f "Configuration\smpl_nwk_config.dat"
  ICCARM.CCOptLevel: 3
  group Components/bsp
    ../../../../../Components/bsp/: bsp.c bsp.h bsp_macros.h
    ../../../../../Components/bsp/boards/STM32/: bsp_button_defs.h bsp_led_defs.h bsp_utility.c
  group Components/mrfi
    ../../../../../Components/mrfi/: mrfi.c
  group Components/nwk
    ../../../../../Components/simpliciti/nwk/: nwk.c nwk_api.c nwk_app.h nwk_frame.c nwk_globals.c nwk_QMgmt.c
    ../../../../../Components/SimpliciTI/nwk/: nwk.h nwk_api.h nwk_frame.h nwk_globals.h nwk_QMgmt.h nwk_types.h
  group Components/nwk applications
    ../../../../../Components/simpliciti/nwk_applications/: nwk_freq.c nwk_ioctl.c nwk_join.c nwk_link.c nwk_mgmt.c nwk_ping.c nwk_pll.c nwk_security.c
  group peer applications/application/Access Point
    ../../../Applications/: main_AP_Async_Listen_autoack.c
  group peer applications/application/Channel Sniffer
    ../../../Applications/: main_ED_Sniffer.c
  group peer applications/application/End Device
    ../../../Applications/: main_manyEDs_autoack.c
  group peer applications/application/Range Extender
    ../../../Applications/: main_AP_RE.c
  group peer applications/Configuration
    Configuration/: smpl_nwk_config.dat
  group peer applications/Configuration/Access Point
    Configuration/Access_Point/: smpl_config.dat
  group peer applications/Configuration/Channel Sniffer
    Configuration/Channel_Sniffer/: smpl_config.dat
  group peer applications/Configuration/End Device
    Configuration/End_Device/: smpl_config.dat
  group peer applications/Configuration/Range Extender
    Configuration/Range_Extender/: smpl_config.dat
  group STM32
    ../../../../../Components/bsp/boards/STM32/: startup_stm32f10x_hd.s system_stm32f10x.c
  group STM32F10x_StdPeriph
    ../../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
