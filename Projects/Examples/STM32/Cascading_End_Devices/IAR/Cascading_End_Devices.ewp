# IAR project Cascading_End_Devices.ewp, settings and files
configuration CC1101-End Device (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MRFI_CC1101
  ICCARM.IExtraOptions: -f "Configuration\End_Device\smpl_config.dat"; -f "Configuration\smpl_nwk_config.dat"
  ICCARM.CCIncludePath2: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\STM32; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\..\..\Components\SimpliciTI\nwk_applications; ..\..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport; ..\..\..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Cascading_End_Devices.srec
  ILINK.IlinkOutputFile: Cascading_End_Devices.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Components/bsp
    ../../../../../Components/bsp/: bsp.c bsp.h bsp_macros.h
    ../../../../../Components/bsp/boards/STM32/: bsp_button_defs.h bsp_led_defs.h
  group Components/mrfi
    ../../../../../Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/nwk
    ../../../../../Components/simpliciti/nwk/: nwk.c nwk_api.c nwk_app.h nwk_frame.c nwk_globals.c nwk_QMgmt.c
    ../../../../../Components/SimpliciTI/nwk/: nwk.h nwk_api.h nwk_frame.h nwk_globals.h nwk_QMgmt.h nwk_types.h
  group Components/nwk applications
    ../../../../../Components/simpliciti/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_pll.c nwk_security.c nwk_security.h
    ../../../../../Components/SimpliciTI/nwk_applications/: nwk_pll.h
  group peer applications/application
    ../../../Applications/: main_babble.c
  group peer applications/Configuration
    Configuration/: smpl_nwk_config.dat
  group peer applications/Configuration/End Device
    Configuration/End_Device/: smpl_config.dat
  group STM32
    ../../../../../Components/bsp/boards/STM32/: startup_stm32f10x_hd.s system_stm32f10x.c
  group STM32F10x_StdPeriph
    ../../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
